# Keil uVision project DEMO.uvprojx, settings and files
target RAM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DEMO +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\User;..\STM32_FWLib\inc;..\STM32_FWLib\src;..\SYSTEM;..\AD7768;..\SYSTEM\ringbuffer;..\SYSTEM\packet
  asm define: VECT_TAB_RAM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../CMSIS/STARTUP/: startup_stm32f10x_md.s
  group User
    ./: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h 1602_4bit.c usart.c
    ../SYSTEM/ringbuffer/: ringbuffer.c
    ../SYSTEM/packet/: packet.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c stm32f10x.h system_stm32f10x.h core_cm3.h
  group STM32_FWLib
    ../STM32_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../STM32_FWLib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group CODE
    ./: delay.c
  group AD7768
    ../AD7768/: AD7768.c demo7768.c mcp_myspi.c
target FLASH (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\User;..\STM32_FWLib\inc;..\STM32_FWLib\src;..\Code\LED;..\Code\KEY;..\Code\GPIO;..\Code\SYSTICK;..\Code\EXTI;..\Code\USART;..\Code\GPIO;..\Code\ad7799NOspi;..\Code\CAN;..\Code\WWDG;..\Code\ADC;..\Code\W25X;..\Code\SPI;..\Code\AD7799;..\Code\EXTI;..\SYSTEM;..\AD7606;..\AD7124;..\MCP3914;..\AD7768
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 6.1.1
